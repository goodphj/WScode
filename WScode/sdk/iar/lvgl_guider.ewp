# IAR project lvgl_guider.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT798S_M33_0 NXP MIMXRT798S_M33_0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; GCID_REV_CID=gc555/0x423_ECO; CUSTOM_VGLITE_MEMORY_CONFIG=0; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; MCUX_DBI_LEGACY=0; DBI_USE_MIPI_PANEL=1; SDK_DEBUGCONSOLE_UART=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT798SGFOB_cm33_core0; MIMXRT798S_cm33_core0_SERIES; BOOT_HEADER_ENABLE=1; LV_CONF_INCLUDE_SIMPLE=1; SDK_OS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pa092,Pa093,Pa181,Pa205,Pe009,Pe186,Pe188,Pa089,Pe236,Pe111,Pe546,Pe191,Pe177
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../Core/source/mcux_config.h
  ICCARM.CCIncludePath2: ../Core/board; ../Core/source; ../Core/CMSIS; ../Core/CMSIS/m-profile; ../Core/component/uart; ../../custom; ../Core/device; ../Core/device/periph; ../Core/drivers; ../Core/flash_config; ../Core/freertos/freertos-kernel/include; ../Core/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../Core/freertos/freertos-kernel/template; ../Core/freertos/freertos-kernel/template/ARM_CM33_3_priority_bits; ../../generated; ../../generated/guider_customer_fonts; ../../generated/guider_fonts; ../Core/lcdc; ../Core/lvgl; ../Core/lvgl/src; ../Core/lvgl/src/font; ../Core/lvgl/src/draw/nxp/vglite; ../Core/touchpanel; ../Core/utilities; ../Core/utilities/debug_console_lite; ../Core/utilities/str; ../Core/vglite/VGLite; ../Core/vglite/VGLite/Series/gc255/0x40A; ../Core/vglite/VGLite/Series/gc355/0x0_1216; ../Core/vglite/VGLite/Series/gc555/0x423_ECO; ../Core/vglite/VGLite/rtos; ../Core/vglite/VGLiteKernel; ../Core/vglite/VGLiteKernel/rtos; ../Core/vglite/inc; ../Core/video
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT798SGFOB_cm33_core0; MIMXRT798S_cm33_core0_SERIES
  AARM.AUserIncludes: ../Core/source; ../Core/CMSIS; ../Core/CMSIS/m-profile; ../Core/component/uart; ../Core/device; ../Core/device/periph; ../Core/drivers; ../Core/flash_config; ../Core/freertos/freertos-kernel/include; ../Core/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../Core/freertos/freertos-kernel/template; ../Core/freertos/freertos-kernel/template/ARM_CM33_3_priority_bits; ../Core/lcdc; ../Core/lvgl; ../Core/lvgl/src; ../Core/lvgl/src/font; ../Core/lvgl/src/draw/nxp/vglite; ../Core/periph; ../Core/touchpanel; ../Core/utilities; ../Core/utilities/debug_console_lite; ../Core/utilities/str; ../Core/vglite/VGLite; ../Core/vglite/VGLite/Series/gc255/0x40A; ../Core/vglite/VGLite/Series/gc355/0x0_1216; ../Core/vglite/VGLite/Series/gc555/0x423_ECO; ../Core/vglite/VGLite/rtos; ../Core/vglite/VGLiteKernel; ../Core/vglite/VGLiteKernel/rtos; ../Core/vglite/inc; ../Core/video
  AARM.PreInclude: ../Core/source/mcux_config.h
  OBJCOPY.OOCOutputFile: lvgl_guider.bin
  ILINK.IlinkOutputFile: lvgl_guider.out
  ILINK.IlinkIcfFile: MIMXRT798S/iar/MIMXRT798Sxxxx_cm33_core0_ram.icf
  ILINK.IlinkExtraOptions: --redirect  __iar_sh_stdout=__iar_sh_stdout_swo
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: MIMXRT798S/iar/MIMXRT798Sxxxx_cm33_core0_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; GCID_REV_CID=gc555/0x423_ECO; CUSTOM_VGLITE_MEMORY_CONFIG=0; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_ENABLE_PSRAM_CACHE=0; SSD1963_DATA_WITDH=8; FLEXIO_MCULCD_DATA_BUS_WIDTH=8; MCUX_DBI_LEGACY=0; DBI_USE_MIPI_PANEL=1; SDK_DEBUGCONSOLE_UART=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT798SGFOB_cm33_core0; MIMXRT798S_cm33_core0_SERIES; BOOT_HEADER_ENABLE=1; LV_CONF_INCLUDE_SIMPLE=1; SDK_OS_FREE_RTOS
  ICCARM.CCOptLevel: 3
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: as above
  group board
    ../Core/board/: board.c board.h clock_config.c clock_config.h
  group CMSIS
    ../Core/CMSIS/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../Core/CMSIS/m-profile/: armv8m_mpu.h cmsis_iccarm_m.h
  group component/uart
    ../Core/component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group custom
    ../../custom/: custom.c custom.h custom.mk lv_conf_ext.h
  group device
    ../Core/device/: fsl_device_registers.h MIMXRT798S_cm33_core0.h MIMXRT798S_cm33_core0_COMMON.h MIMXRT798S_cm33_core0_features.h system_MIMXRT798S_cm33_core0.c system_MIMXRT798S_cm33_core0.h
  group device/periph
    ../Core/device/periph/: PERI_ADC.h PERI_AHBSC0.h PERI_AHBSC3.h PERI_AHBSC4.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CDOG.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CLKCTL2.h PERI_CLKCTL3.h PERI_CLKCTL4.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUG_MAILBOX.h PERI_DMA.h PERI_ELS.h PERI_FLEXIO.h PERI_FREQME.h PERI_FRO.h PERI_GDET.h PERI_GLIKEY.h PERI_GPIO.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX0.h PERI_INPUTMUX1.h PERI_IOPCTL0.h PERI_IOPCTL1.h PERI_IOPCTL2.h PERI_ITRC.h PERI_JPEGDEC.h PERI_JPGDECWRP.h PERI_LCDIF.h PERI_LP_FLEXCOMM.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_MIPI_DSI_HOST.h PERI_MMU.h PERI_MRT.h PERI_MU.h PERI_NIC.h PERI_OCOTP.h PERI_OSC32KNP.h PERI_OSCCA.h PERI_OSTIMER.h PERI_PDM.h PERI_PINT.h PERI_PKC.h PERI_PMC.h PERI_PNGDEC.h PERI_PUF.h PERI_PVTS.h PERI_ROMCP.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RSTCTL2.h PERI_RSTCTL3.h PERI_RSTCTL4.h PERI_RTC.h PERI_SCT.h PERI_SDADC.h PERI_SEMA42.h PERI_SLEEPCON0.h PERI_SLEEPCON1.h PERI_SYSCON0.h PERI_SYSCON1.h PERI_SYSCON2.h PERI_SYSCON3.h PERI_SYSCON4.h PERI_SYSPM.h PERI_TRNG.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h PERI_XCACHE.h PERI_XSPI.h
  group doc
    ../Core/doc/: examples_shared_readme.md lvgl_examples_readme.md readme.md
  group drivers
    ../Core/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_edma.c fsl_edma.h fsl_edma_core.h fsl_edma_soc.c fsl_edma_soc.h fsl_flexio.c fsl_flexio.h fsl_flexio_mculcd.c fsl_flexio_mculcd.h fsl_flexio_mculcd_edma.c fsl_flexio_mculcd_edma.h fsl_glikey.c fsl_glikey.h fsl_gpio.c fsl_gpio.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_iopctl.h fsl_lcdif.c fsl_lcdif.h fsl_lpflexcomm.c fsl_lpflexcomm.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_soc_mipi_dsi.h fsl_xspi.c fsl_xspi.h
  group flash_config
    ../Core/flash_config/: flash_config.c flash_config.h
  group freertos/freertos-kernel
    ../Core/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../Core/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group freertos/freertos-kernel/portable
    ../Core/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../Core/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/portable/MemMang
    ../Core/freertos/freertos-kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/freertos-kernel/template
    ../Core/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group generated
    ../../generated/: events_init.c events_init.h generated.mk gui_guider.c gui_guider.h setup_scr_air_quality.c setup_scr_battery.c setup_scr_blood_oxygen.c setup_scr_blood_pressure.c setup_scr_call.c setup_scr_car_lock.c setup_scr_car_start.c setup_scr_contact_list.c setup_scr_ECG.c setup_scr_find_device.c setup_scr_fitness.c setup_scr_flight.c setup_scr_flight_info.c setup_scr_home_analog.c setup_scr_home_digital.c setup_scr_info.c setup_scr_listening.c setup_scr_menstrual.c setup_scr_message_info.c setup_scr_message_list.c setup_scr_music_player.c setup_scr_navigation.c setup_scr_not_recognized.c setup_scr_payment.c setup_scr_payment_info.c setup_scr_play_sound.c setup_scr_position.c setup_scr_recognized.c setup_scr_settings.c setup_scr_sleep.c setup_scr_standup.c setup_scr_step.c setup_scr_stress_level.c setup_scr_weather.c setup_scr_weather_hour.c setup_scr_weather_week.c widgets_init.c widgets_init.h
  group generated/guider_customer_fonts
    ../../generated/guider_customer_fonts/: guider_customer_fonts.h guider_customer_fonts.mk
  group generated/guider_fonts
    ../../generated/guider_fonts/: fonts_list.mk guider_fonts.mk lv_font_montserratMedium_118.c lv_font_montserratMedium_130.c lv_font_montserratMedium_14.c lv_font_montserratMedium_142.c lv_font_montserratMedium_178.c lv_font_montserratMedium_19.c lv_font_montserratMedium_21.c lv_font_montserratMedium_23.c lv_font_montserratMedium_26.c lv_font_montserratMedium_28.c lv_font_montserratMedium_29.c lv_font_montserratMedium_30.c lv_font_montserratMedium_35.c lv_font_montserratMedium_47.c
  group generated/images
    ../../generated/images/: images.mk images_list.mk images_md5.json lottie_list.mk _dot_ARGB8888_9x9.c _icn_audio_back_ARGB8888_20x30.c _icn_audio_next_ARGB8888_20x30.c _icn_audio_play_ARGB8888_28x45.c _icn_audio_rnd_ARGB8888_39x34.c _icn_big_weather_cloud_ARGB8888_78x59.c _icn_fitness_ARGB8888_47x47.c _icn_flash_blue_ARGB8888_20x24.c _icn_heart_ARGB8888_33x28.c _icn_home_ARGB8888_30x27.c _icn_home_ARGB8888_30x28.c _icn_insta_ARGB8888_42x42.c _icn_message_ARGB8888_23x29.c _icn_mute_ARGB8888_40x32.c _icn_phone_ARGB8888_31x25.c _icn_small_burn_ARGB8888_24x28.c _icn_small_pos_ARGB8888_22x29.c _icn_small_pulse_ARGB8888_29x26.c _icn_small_time_ARGB8888_29x29.c _icn_small_weather_1_ARGB8888_49x38.c _icn_small_weather_2_ARGB8888_48x45.c _icn_small_weather_3_ARGB8888_35x38.c _icn_sport_ARGB8888_23x29.c _icn_step_red_ARGB8888_20x24.c _icn_travel_ARGB8888_47x47.c _icn_unmute_ARGB8888_40x32.c _icn_water_ARGB8888_38x52.c _icn_weather_1_ARGB8888_48x39.c _icn_whatsapp_ARGB8888_46x46.c _icn_whatsapp_ARGB8888_80x80.c _img_arrow_left_ARGB8888_12x38.c _img_arrow_right_ARGB8888_12x38.c _img_audio_album_RGB565_466x466_tresh.c _img_avatar_1_ARGB8888_72x72.c _img_avatar_2_ARGB8888_72x72.c _img_avatar_3_ARGB8888_72x72.c _img_avatar_4_ARGB8888_72x70.c _img_bg_2_RGB565_466x466_tresh.c _img_bg_analog_RGB565_466x466_tresh.c _img_bg_digital_RGB565_466x466_tresh.c _img_bg_health_RGB565_466x466_tresh.c _img_bg_travel_RGB565_466x466_tresh.c _img_call_erica_ARGB8888_466x298_tresh.c _img_card_1_ARGB8888_316x198_tresh.c _img_car_ARGB8888_99x99.c _img_car_lock_1_ARGB8888_139x105.c _img_car_lock_2_ARGB8888_74x66.c _img_chart_battery_ARGB8888_383x98.c _img_chart_sleep_ARGB8888_399x160.c _img_clockwise_hour_ARGB8888_18x98.c _img_clockwise_min_ARGB8888_18x157.c _img_clockwise_sec_ARGB8888_30x180.c _img_cloud_RGB565_696x466_tresh.c _img_ekg_ARGB8888_152x134.c _img_find_device2_ARGB8888_199x199.c _img_find_device_ARGB8888_137x135.c _img_green_btn_ARGB8888_218x218_tresh.c _img_header_bg_ARGB8888_466x89.c _img_heart_ARGB8888_60x51.c _img_line_1_ARGB8888_275x2.c _img_line_2_ARGB8888_297x2.c _img_line_2_ARGB8888_331x2.c _img_line_3_ARGB8888_2x103.c _img_map_RGB565_466x466.c _img_menstrual_chart_ARGB8888_262x269.c _img_menu_ARGB8888_13x118.c _img_menu_ARGB8888_13x139.c _img_mic_1_ARGB8888_225x231_tresh.c _img_mic_2_ARGB8888_225x231_tresh.c _img_mic_3_ARGB8888_225x231_tresh.c _img_nav_1_ARGB8888_127x145.c _img_pause_ARGB8888_28x45.c _img_payment_ok_ARGB8888_149x148.c _img_plane_2_ARGB8888_398x57.c _img_qr_code_ARGB8888_246x288.c _img_red_btn_ARGB8888_218x218_tresh.c _img_small_nav_1_ARGB8888_40x45.c _img_stand_up_ARGB8888_99x99.c _img_step_small_ARGB8888_33x53.c _img_stress_level_ARGB8888_79x124.c _img_sun_RGB565_466x466.c _NXP_Logo_ARGB8888_100x49.c _text_endcall_ARGB8888_30x40.c _text_favorites_ARGB8888_66x92.c _text_home_ARGB8888_45x60.c _text_message_ARGB8888_83x83.c _text_select_ARGB8888_50x66.c _text_sport_ARGB8888_59x59.c _text_start_stop_ARGB8888_45x60.c _text_volume_ARGB8888_32x84.c _text_volume_ARGB8888_32x86.c
  group lcdc
    ../Core/lcdc/: fsl_ssd1963.c fsl_ssd1963.h
  group lvgl
    ../Core/lvgl/: LICENCE.txt lv_conf_template.h lv_version.h lvgl.h lvgl_private.h
  group lvgl/src
    ../Core/lvgl/src/: lv_api_map_v8.h lv_api_map_v9_0.h lv_api_map_v9_1.h lv_conf_internal.h lv_conf_kconfig.h lv_init.c lv_init.h lvgl.h lvgl_private.h
  group lvgl/src/core
    ../Core/lvgl/src/core/: lv_global.h lv_group.c lv_group.h lv_group_private.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_class_private.h lv_obj_draw.c lv_obj_draw.h lv_obj_draw_private.h lv_obj_event.c lv_obj_event.h lv_obj_event_private.h lv_obj_id_builtin.c lv_obj_pos.c lv_obj_pos.h lv_obj_private.h lv_obj_property.c lv_obj_property.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_scroll_private.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_style_private.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_refr_private.h
  group lvgl/src/display
    ../Core/lvgl/src/display/: lv_display.c lv_display.h lv_display_private.h
  group lvgl/src/draw
    ../Core/lvgl/src/draw/: lv_draw.c lv_draw.h lv_draw_3d.c lv_draw_3d.h lv_draw_arc.c lv_draw_arc.h lv_draw_buf.c lv_draw_buf.h lv_draw_buf_private.h lv_draw_image.c lv_draw_image.h lv_draw_image_private.h lv_draw_label.c lv_draw_label.h lv_draw_label_private.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_mask_private.h lv_draw_private.h lv_draw_rect.c lv_draw_rect.h lv_draw_rect_private.h lv_draw_triangle.c lv_draw_triangle.h lv_draw_triangle_private.h lv_draw_vector.c lv_draw_vector.h lv_draw_vector_private.h lv_image_decoder.c lv_image_decoder.h lv_image_decoder_private.h lv_image_dsc.h
  group lvgl/src/draw/dma2d
    ../Core/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d.h lv_draw_dma2d_fill.c lv_draw_dma2d_img.c lv_draw_dma2d_private.h
  group lvgl/src/draw/nema_gfx
    ../Core/lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx.h lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_utils.h lv_nema_gfx_path.c lv_nema_gfx_path.h
  group lvgl/src/draw/nxp/g2d
    ../Core/lvgl/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d.h lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_buf_map.h lv_g2d_utils.c lv_g2d_utils.h
  group lvgl/src/draw/nxp/pxp
    ../Core/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp.h lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_cfg.h lv_pxp_osa.c lv_pxp_osa.h lv_pxp_utils.c lv_pxp_utils.h
  group lvgl/src/draw/nxp/vglite
    ../Core/lvgl/src/draw/nxp/vglite/: lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite.h lv_draw_vglite_arc.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_draw_vglite_line.c lv_draw_vglite_triangle.c lv_vglite_buf.c lv_vglite_buf.h lv_vglite_matrix.c lv_vglite_matrix.h lv_vglite_path.c lv_vglite_path.h lv_vglite_utils.c lv_vglite_utils.h
  group lvgl/src/draw/opengles
    ../Core/lvgl/src/draw/opengles/: lv_draw_opengles.c lv_draw_opengles.h
  group lvgl/src/draw/renesas/dave2d
    ../Core/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d.h lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c lv_draw_dave2d_utils.h
  group lvgl/src/draw/sdl
    ../Core/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl.h
  group lvgl/src/draw/sw
    ../Core/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_grad.h lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask.h lv_draw_sw_mask_private.h lv_draw_sw_mask_rect.c lv_draw_sw_private.h lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_utils.h lv_draw_sw_vector.c
  group lvgl/src/draw/sw/arm2d
    ../Core/lvgl/src/draw/sw/arm2d/: lv_draw_sw_arm2d.h lv_draw_sw_helium.h
  group lvgl/src/draw/sw/blend
    ../Core/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_blend_private.h lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_al88.h lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888.h lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_argb8888_premultiplied.h lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_i1.h lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_l8.h lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565.h lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb565_swapped.h lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend_to_rgb888.h
  group lvgl/src/draw/sw/blend/arm2d
    ../Core/lvgl/src/draw/sw/blend/arm2d/: lv_blend_arm2d.h
  group lvgl/src/draw/sw/blend/helium
    ../Core/lvgl/src/draw/sw/blend/helium/: lv_blend_helium.h
  group lvgl/src/draw/sw/blend/neon
    ../Core/lvgl/src/draw/sw/blend/neon/: lv_blend_neon.h
  group lvgl/src/draw/vg_lite
    ../Core/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite.h lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_type.h lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_decoder.h lv_vg_lite_grad.c lv_vg_lite_grad.h lv_vg_lite_math.c lv_vg_lite_math.h lv_vg_lite_path.c lv_vg_lite_path.h lv_vg_lite_pending.c lv_vg_lite_pending.h lv_vg_lite_stroke.c lv_vg_lite_stroke.h lv_vg_lite_utils.c lv_vg_lite_utils.h
  group lvgl/src/drivers
    ../Core/lvgl/src/drivers/: lv_drivers.h
  group lvgl/src/drivers/display/drm
    ../Core/lvgl/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm.h
  group lvgl/src/drivers/display/fb
    ../Core/lvgl/src/drivers/display/fb/: lv_linux_fbdev.c lv_linux_fbdev.h
  group lvgl/src/drivers/display/ft81x
    ../Core/lvgl/src/drivers/display/ft81x/: lv_ft81x.c lv_ft81x.h lv_ft81x_defines.h
  group lvgl/src/drivers/display/ili9341
    ../Core/lvgl/src/drivers/display/ili9341/: lv_ili9341.c lv_ili9341.h
  group lvgl/src/drivers/display/lcd
    ../Core/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c lv_lcd_generic_mipi.h
  group lvgl/src/drivers/display/renesas_glcdc
    ../Core/lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c lv_renesas_glcdc.h
  group lvgl/src/drivers/display/st7735
    ../Core/lvgl/src/drivers/display/st7735/: lv_st7735.c lv_st7735.h
  group lvgl/src/drivers/display/st7789
    ../Core/lvgl/src/drivers/display/st7789/: lv_st7789.c lv_st7789.h
  group lvgl/src/drivers/display/st7796
    ../Core/lvgl/src/drivers/display/st7796/: lv_st7796.c lv_st7796.h
  group lvgl/src/drivers/display/st_ltdc
    ../Core/lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c lv_st_ltdc.h
  group lvgl/src/drivers/display/tft_espi
    ../Core/lvgl/src/drivers/display/tft_espi/: lv_tft_espi.h
  group lvgl/src/drivers/evdev
    ../Core/lvgl/src/drivers/evdev/: lv_evdev.c lv_evdev.h lv_evdev_private.h
  group lvgl/src/drivers/glfw
    ../Core/lvgl/src/drivers/glfw/: lv_glfw_window.c lv_glfw_window.h lv_glfw_window_private.h lv_opengles_debug.c lv_opengles_debug.h lv_opengles_driver.c lv_opengles_driver.h lv_opengles_texture.c lv_opengles_texture.h
  group lvgl/src/drivers/libinput
    ../Core/lvgl/src/drivers/libinput/: lv_libinput.c lv_libinput.h lv_libinput_private.h lv_xkb.c lv_xkb.h lv_xkb_private.h
  group lvgl/src/drivers/nuttx
    ../Core/lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_cache.h lv_nuttx_entry.c lv_nuttx_entry.h lv_nuttx_fbdev.c lv_nuttx_fbdev.h lv_nuttx_image_cache.c lv_nuttx_image_cache.h lv_nuttx_lcd.c lv_nuttx_lcd.h lv_nuttx_libuv.c lv_nuttx_libuv.h lv_nuttx_profiler.c lv_nuttx_profiler.h lv_nuttx_touchscreen.c lv_nuttx_touchscreen.h
  group lvgl/src/drivers/qnx
    ../Core/lvgl/src/drivers/qnx/: lv_qnx.c lv_qnx.h
  group lvgl/src/drivers/sdl
    ../Core/lvgl/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_keyboard.h lv_sdl_mouse.c lv_sdl_mouse.h lv_sdl_mousewheel.c lv_sdl_mousewheel.h lv_sdl_private.h lv_sdl_window.c lv_sdl_window.h
  group lvgl/src/drivers/uefi
    ../Core/lvgl/src/drivers/uefi/: lv_uefi.h lv_uefi_context.c lv_uefi_context.h lv_uefi_display.c lv_uefi_display.h lv_uefi_edk2.h lv_uefi_gnu_efi.h lv_uefi_indev.h lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c lv_uefi_private.h lv_uefi_std_wrapper.h
  group lvgl/src/drivers/wayland
    ../Core/lvgl/src/drivers/wayland/: lv_wayland.c lv_wayland.h lv_wayland_private.h lv_wayland_smm.c lv_wayland_smm.h lv_wl_cache.c lv_wl_dmabuf.c lv_wl_keyboard.c lv_wl_keyboard.h lv_wl_pointer.c lv_wl_pointer.h lv_wl_pointer_axis.c lv_wl_pointer_axis.h lv_wl_seat.c lv_wl_shell.c lv_wl_shm.c lv_wl_touch.c lv_wl_touch.h lv_wl_window.c lv_wl_window.h lv_wl_window_decorations.c lv_wl_xdg_shell.c
  group lvgl/src/drivers/windows
    ../Core/lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_context.h lv_windows_display.c lv_windows_display.h lv_windows_input.c lv_windows_input.h lv_windows_input_private.h
  group lvgl/src/drivers/x11
    ../Core/lvgl/src/drivers/x11/: lv_x11.h lv_x11_display.c lv_x11_input.c
  group lvgl/src/font
    ../Core/lvgl/src/font/: lv_binfont_loader.c lv_binfont_loader.h lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_fmt_txt_private.h lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_symbol_def.h
  group lvgl/src/indev
    ../Core/lvgl/src/indev/: lv_indev.c lv_indev.h lv_indev_gesture.c lv_indev_gesture.h lv_indev_gesture_private.h lv_indev_private.h lv_indev_scroll.c lv_indev_scroll.h
  group lvgl/src/layouts
    ../Core/lvgl/src/layouts/: lv_layout.c lv_layout.h lv_layout_private.h
  group lvgl/src/layouts/flex
    ../Core/lvgl/src/layouts/flex/: lv_flex.c lv_flex.h
  group lvgl/src/layouts/grid
    ../Core/lvgl/src/layouts/grid/: lv_grid.c lv_grid.h
  group lvgl/src/libs/barcode
    ../Core/lvgl/src/libs/barcode/: code128.c code128.h lv_barcode.c lv_barcode.h lv_barcode_private.h
  group lvgl/src/libs/bin_decoder
    ../Core/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c lv_bin_decoder.h
  group lvgl/src/libs/bmp
    ../Core/lvgl/src/libs/bmp/: lv_bmp.c lv_bmp.h
  group lvgl/src/libs/expat
    ../Core/lvgl/src/libs/expat/: ascii.h asciitab.h expat.h expat_config.h expat_external.h iasciitab.h internal.h latin1tab.h nametab.h siphash.h utf8tab.h winconfig.h xmlparse.c xmlrole.c xmlrole.h xmltok.c xmltok.h xmltok_impl.c xmltok_impl.h xmltok_ns.c
  group lvgl/src/libs/ffmpeg
    ../Core/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.h lv_ffmpeg_private.h
  group lvgl/src/libs/freetype
    ../Core/lvgl/src/libs/freetype/: ftmodule.h ftoption.h lv_freetype.c lv_freetype.h lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_freetype_private.h lv_ftsystem.c
  group lvgl/src/libs/fsdrv
    ../Core/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_rawfs.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c lv_fsdrv.h
  group lvgl/src/libs/gif
    ../Core/lvgl/src/libs/gif/: gifdec.c gifdec.h gifdec_mve.h lv_gif.c lv_gif.h lv_gif_private.h
  group lvgl/src/libs/libjpeg_turbo
    ../Core/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c lv_libjpeg_turbo.h
  group lvgl/src/libs/libpng
    ../Core/lvgl/src/libs/libpng/: lv_libpng.c lv_libpng.h
  group lvgl/src/libs/lodepng
    ../Core/lvgl/src/libs/lodepng/: lodepng.c lodepng.h lv_lodepng.c lv_lodepng.h
  group lvgl/src/libs/lz4
    ../Core/lvgl/src/libs/lz4/: lz4.c lz4.h
  group lvgl/src/libs/qrcode
    ../Core/lvgl/src/libs/qrcode/: lv_qrcode.c lv_qrcode.h lv_qrcode_private.h qrcodegen.c qrcodegen.h
  group lvgl/src/libs/rle
    ../Core/lvgl/src/libs/rle/: lv_rle.c lv_rle.h
  group lvgl/src/libs/rlottie
    ../Core/lvgl/src/libs/rlottie/: lv_rlottie.c lv_rlottie.h lv_rlottie_private.h
  group lvgl/src/libs/svg
    ../Core/lvgl/src/libs/svg/: lv_svg.c lv_svg.h lv_svg_decoder.c lv_svg_decoder.h lv_svg_parser.c lv_svg_parser.h lv_svg_render.c lv_svg_render.h lv_svg_token.c lv_svg_token.h
  group lvgl/src/libs/thorvg
    ../Core/lvgl/src/libs/thorvg/: config.h thorvg.h thorvg_capi.h thorvg_lottie.h tvgAnimation.h tvgArray.h tvgBinaryDesc.h tvgCanvas.h tvgCommon.h tvgCompressor.h tvgFill.h tvgFrameModule.h tvgInlist.h tvgIteratorAccessor.h tvgLoader.h tvgLoadModule.h tvgLock.h tvgLottieBuilder.h tvgLottieCommon.h tvgLottieExpressions.h tvgLottieInterpolator.h tvgLottieLoader.h tvgLottieModel.h tvgLottieModifier.h tvgLottieParser.h tvgLottieParserHandler.h tvgLottieProperty.h tvgLottieRenderPooler.h tvgMath.h tvgPaint.h tvgPicture.h tvgRawLoader.h tvgRender.h tvgSaveModule.h tvgScene.h tvgShape.h tvgStr.h tvgSvgCssStyle.h tvgSvgLoader.h tvgSvgLoaderCommon.h tvgSvgPath.h tvgSvgSceneBuilder.h tvgSvgUtil.h tvgSwCommon.h tvgSwRasterAvx.h tvgSwRasterC.h tvgSwRasterNeon.h tvgSwRasterTexmap.h tvgSwRenderer.h tvgTaskScheduler.h tvgText.h tvgXmlParser.h
  group lvgl/src/libs/thorvg/rapidjson
    ../Core/lvgl/src/libs/thorvg/rapidjson/: allocators.h cursorstreamwrapper.h document.h encodedstream.h encodings.h filereadstream.h filewritestream.h fwd.h istreamwrapper.h memorybuffer.h memorystream.h ostreamwrapper.h pointer.h prettywriter.h rapidjson.h reader.h schema.h stream.h stringbuffer.h uri.h writer.h
  group lvgl/src/libs/thorvg/rapidjson/error
    ../Core/lvgl/src/libs/thorvg/rapidjson/error/: en.h error.h
  group lvgl/src/libs/thorvg/rapidjson/internal
    ../Core/lvgl/src/libs/thorvg/rapidjson/internal/: biginteger.h clzll.h diyfp.h dtoa.h ieee754.h itoa.h meta.h pow10.h regex.h stack.h strfunc.h strtod.h swap.h
  group lvgl/src/libs/thorvg/rapidjson/msinttypes
    ../Core/lvgl/src/libs/thorvg/rapidjson/msinttypes/: inttypes.h stdint.h
  group lvgl/src/libs/tiny_ttf
    ../Core/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c lv_tiny_ttf.h stb_rect_pack.h stb_truetype_htcw.h
  group lvgl/src/libs/tjpgd
    ../Core/lvgl/src/libs/tjpgd/: lv_tjpgd.c lv_tjpgd.h tjpgd.c tjpgd.h tjpgdcnf.h
  group lvgl/src/misc
    ../Core/lvgl/src/misc/: lv_anim.c lv_anim.h lv_anim_private.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_area_private.h lv_array.c lv_array.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_bidi_private.h lv_circle_buf.c lv_circle_buf.h lv_color.c lv_color.h lv_color_op.c lv_color_op.h lv_color_op_private.h lv_event.c lv_event.h lv_event_private.h lv_fs.c lv_fs.h lv_fs_private.h lv_grad.c lv_grad.h lv_iter.c lv_iter.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_math.c lv_math.h lv_matrix.c lv_matrix.h lv_palette.c lv_palette.h lv_profiler.h lv_profiler_builtin.c lv_profiler_builtin.h lv_profiler_builtin_private.h lv_rb.c lv_rb.h lv_rb_private.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_style_private.h lv_templ.c lv_templ.h lv_text.c lv_text.h lv_text_ap.c lv_text_ap.h lv_text_private.h lv_timer.c lv_timer.h lv_timer_private.h lv_tree.c lv_tree.h lv_types.h lv_utils.c lv_utils.h
  group lvgl/src/misc/cache
    ../Core/lvgl/src/misc/cache/: lv_cache.c lv_cache.h lv_cache_entry.c lv_cache_entry.h lv_cache_entry_private.h lv_cache_private.h
  group lvgl/src/misc/cache/class
    ../Core/lvgl/src/misc/cache/class/: lv_cache_class.h lv_cache_lru_ll.c lv_cache_lru_ll.h lv_cache_lru_rb.c lv_cache_lru_rb.h
  group lvgl/src/misc/cache/instance
    ../Core/lvgl/src/misc/cache/instance/: lv_cache_instance.h lv_image_cache.c lv_image_cache.h lv_image_header_cache.c lv_image_header_cache.h
  group lvgl/src/osal
    ../Core/lvgl/src/osal/: lv_cmsis_rtos2.c lv_cmsis_rtos2.h lv_freertos.c lv_freertos.h lv_linux.c lv_linux_private.h lv_mqx.c lv_mqx.h lv_os.c lv_os.h lv_os_none.c lv_os_none.h lv_os_private.h lv_pthread.c lv_pthread.h lv_rtthread.c lv_rtthread.h lv_sdl2.c lv_sdl2.h lv_windows.c lv_windows.h
  group lvgl/src/others/file_explorer
    ../Core/lvgl/src/others/file_explorer/: lv_file_explorer.c lv_file_explorer.h lv_file_explorer_private.h
  group lvgl/src/others/font_manager
    ../Core/lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager.h lv_font_manager_recycle.c lv_font_manager_recycle.h
  group lvgl/src/others/fragment
    ../Core/lvgl/src/others/fragment/: lv_fragment.c lv_fragment.h lv_fragment_manager.c lv_fragment_private.h
  group lvgl/src/others/gridnav
    ../Core/lvgl/src/others/gridnav/: lv_gridnav.c lv_gridnav.h
  group lvgl/src/others/ime
    ../Core/lvgl/src/others/ime/: lv_ime_pinyin.c lv_ime_pinyin.h lv_ime_pinyin_private.h
  group lvgl/src/others/imgfont
    ../Core/lvgl/src/others/imgfont/: lv_imgfont.c lv_imgfont.h
  group lvgl/src/others/monkey
    ../Core/lvgl/src/others/monkey/: lv_monkey.c lv_monkey.h lv_monkey_private.h
  group lvgl/src/others/observer
    ../Core/lvgl/src/others/observer/: lv_observer.c lv_observer.h lv_observer_private.h
  group lvgl/src/others/snapshot
    ../Core/lvgl/src/others/snapshot/: lv_snapshot.c lv_snapshot.h
  group lvgl/src/others/sysmon
    ../Core/lvgl/src/others/sysmon/: lv_sysmon.c lv_sysmon.h lv_sysmon_private.h
  group lvgl/src/others/test
    ../Core/lvgl/src/others/test/: lv_test.h lv_test_display.c lv_test_display.h lv_test_helpers.c lv_test_helpers.h lv_test_indev.c lv_test_indev.h lv_test_indev_gesture.c lv_test_indev_gesture.h lv_test_private.h lv_test_screenshot_compare.c lv_test_screenshot_compare.h
  group lvgl/src/others/vg_lite_tvg
    ../Core/lvgl/src/others/vg_lite_tvg/: vg_lite.h vg_lite_matrix.c
  group lvgl/src/others/xml
    ../Core/lvgl/src/others/xml/: lv_xml.c lv_xml.h lv_xml_base_types.c lv_xml_base_types.h lv_xml_component.c lv_xml_component.h lv_xml_component_private.h lv_xml_parser.c lv_xml_parser.h lv_xml_private.h lv_xml_style.c lv_xml_style.h lv_xml_update.c lv_xml_update.h lv_xml_utils.c lv_xml_utils.h lv_xml_widget.c lv_xml_widget.h
  group lvgl/src/others/xml/parsers
    ../Core/lvgl/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_arc_parser.h lv_xml_bar_parser.c lv_xml_bar_parser.h lv_xml_button_parser.c lv_xml_button_parser.h lv_xml_buttonmatrix_parser.c lv_xml_buttonmatrix_parser.h lv_xml_calendar_parser.c lv_xml_calendar_parser.h lv_xml_canvas_parser.c lv_xml_canvas_parser.h lv_xml_chart_parser.c lv_xml_chart_parser.h lv_xml_checkbox_parser.c lv_xml_checkbox_parser.h lv_xml_dropdown_parser.c lv_xml_dropdown_parser.h lv_xml_event_parser.c lv_xml_event_parser.h lv_xml_image_parser.c lv_xml_image_parser.h lv_xml_keyboard_parser.c lv_xml_keyboard_parser.h lv_xml_label_parser.c lv_xml_label_parser.h lv_xml_obj_parser.c lv_xml_obj_parser.h lv_xml_roller_parser.c lv_xml_roller_parser.h lv_xml_scale_parser.c lv_xml_scale_parser.h lv_xml_slider_parser.c lv_xml_slider_parser.h lv_xml_spangroup_parser.c lv_xml_spangroup_parser.h lv_xml_table_parser.c lv_xml_table_parser.h lv_xml_tabview_parser.c lv_xml_tabview_parser.h lv_xml_textarea_parser.c lv_xml_textarea_parser.h
  group lvgl/src/stdlib
    ../Core/lvgl/src/stdlib/: lv_mem.c lv_mem.h lv_mem_private.h lv_sprintf.h lv_string.h
  group lvgl/src/stdlib/builtin
    ../Core/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c lv_tlsf.h lv_tlsf_private.h
  group lvgl/src/stdlib/clib
    ../Core/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
  group lvgl/src/stdlib/micropython
    ../Core/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
  group lvgl/src/stdlib/rtthread
    ../Core/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
  group lvgl/src/stdlib/uefi
    ../Core/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
  group lvgl/src/themes
    ../Core/lvgl/src/themes/: lv_theme.c lv_theme.h lv_theme_private.h
  group lvgl/src/themes/default
    ../Core/lvgl/src/themes/default/: lv_theme_default.c lv_theme_default.h
  group lvgl/src/themes/mono
    ../Core/lvgl/src/themes/mono/: lv_theme_mono.c lv_theme_mono.h
  group lvgl/src/themes/simple
    ../Core/lvgl/src/themes/simple/: lv_theme_simple.c lv_theme_simple.h
  group lvgl/src/tick
    ../Core/lvgl/src/tick/: lv_tick.c lv_tick.h lv_tick_private.h
  group lvgl/src/widgets/3dtexture
    ../Core/lvgl/src/widgets/3dtexture/: lv_3dtexture.c lv_3dtexture.h lv_3dtexture_private.h
  group lvgl/src/widgets/animimage
    ../Core/lvgl/src/widgets/animimage/: lv_animimage.c lv_animimage.h lv_animimage_private.h
  group lvgl/src/widgets/arc
    ../Core/lvgl/src/widgets/arc/: lv_arc.c lv_arc.h lv_arc_private.h
  group lvgl/src/widgets/bar
    ../Core/lvgl/src/widgets/bar/: lv_bar.c lv_bar.h lv_bar_private.h
  group lvgl/src/widgets/button
    ../Core/lvgl/src/widgets/button/: lv_button.c lv_button.h lv_button_private.h
  group lvgl/src/widgets/buttonmatrix
    ../Core/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c lv_buttonmatrix.h lv_buttonmatrix_private.h
  group lvgl/src/widgets/calendar
    ../Core/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_chinese.c lv_calendar_chinese.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h lv_calendar_private.h
  group lvgl/src/widgets/canvas
    ../Core/lvgl/src/widgets/canvas/: lv_canvas.c lv_canvas.h lv_canvas_private.h
  group lvgl/src/widgets/chart
    ../Core/lvgl/src/widgets/chart/: lv_chart.c lv_chart.h lv_chart_private.h
  group lvgl/src/widgets/checkbox
    ../Core/lvgl/src/widgets/checkbox/: lv_checkbox.c lv_checkbox.h lv_checkbox_private.h
  group lvgl/src/widgets/dropdown
    ../Core/lvgl/src/widgets/dropdown/: lv_dropdown.c lv_dropdown.h lv_dropdown_private.h
  group lvgl/src/widgets/image
    ../Core/lvgl/src/widgets/image/: lv_image.c lv_image.h lv_image_private.h
  group lvgl/src/widgets/imagebutton
    ../Core/lvgl/src/widgets/imagebutton/: lv_imagebutton.c lv_imagebutton.h lv_imagebutton_private.h
  group lvgl/src/widgets/keyboard
    ../Core/lvgl/src/widgets/keyboard/: lv_keyboard.c lv_keyboard.h lv_keyboard_private.h
  group lvgl/src/widgets/label
    ../Core/lvgl/src/widgets/label/: lv_label.c lv_label.h lv_label_private.h
  group lvgl/src/widgets/led
    ../Core/lvgl/src/widgets/led/: lv_led.c lv_led.h lv_led_private.h
  group lvgl/src/widgets/line
    ../Core/lvgl/src/widgets/line/: lv_line.c lv_line.h lv_line_private.h
  group lvgl/src/widgets/list
    ../Core/lvgl/src/widgets/list/: lv_list.c lv_list.h
  group lvgl/src/widgets/lottie
    ../Core/lvgl/src/widgets/lottie/: lv_lottie.c lv_lottie.h lv_lottie_private.h
  group lvgl/src/widgets/menu
    ../Core/lvgl/src/widgets/menu/: lv_menu.c lv_menu.h lv_menu_private.h
  group lvgl/src/widgets/msgbox
    ../Core/lvgl/src/widgets/msgbox/: lv_msgbox.c lv_msgbox.h lv_msgbox_private.h
  group lvgl/src/widgets/objx_templ
    ../Core/lvgl/src/widgets/objx_templ/: lv_objx_templ.c lv_objx_templ.h
  group lvgl/src/widgets/property
    ../Core/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_obj_property_names.h lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_style_properties.h lv_textarea_properties.c
  group lvgl/src/widgets/roller
    ../Core/lvgl/src/widgets/roller/: lv_roller.c lv_roller.h lv_roller_private.h
  group lvgl/src/widgets/scale
    ../Core/lvgl/src/widgets/scale/: lv_scale.c lv_scale.h lv_scale_private.h
  group lvgl/src/widgets/slider
    ../Core/lvgl/src/widgets/slider/: lv_slider.c lv_slider.h lv_slider_private.h
  group lvgl/src/widgets/span
    ../Core/lvgl/src/widgets/span/: lv_span.c lv_span.h lv_span_private.h
  group lvgl/src/widgets/spinbox
    ../Core/lvgl/src/widgets/spinbox/: lv_spinbox.c lv_spinbox.h lv_spinbox_private.h
  group lvgl/src/widgets/spinner
    ../Core/lvgl/src/widgets/spinner/: lv_spinner.c lv_spinner.h
  group lvgl/src/widgets/switch
    ../Core/lvgl/src/widgets/switch/: lv_switch.c lv_switch.h lv_switch_private.h
  group lvgl/src/widgets/table
    ../Core/lvgl/src/widgets/table/: lv_table.c lv_table.h lv_table_private.h
  group lvgl/src/widgets/tabview
    ../Core/lvgl/src/widgets/tabview/: lv_tabview.c lv_tabview.h lv_tabview_private.h
  group lvgl/src/widgets/textarea
    ../Core/lvgl/src/widgets/textarea/: lv_textarea.c lv_textarea.h lv_textarea_private.h
  group lvgl/src/widgets/tileview
    ../Core/lvgl/src/widgets/tileview/: lv_tileview.c lv_tileview.h lv_tileview_private.h
  group lvgl/src/widgets/win
    ../Core/lvgl/src/widgets/win/: lv_win.c lv_win.h lv_win_private.h
  group MIMXRT798S/iar
    MIMXRT798S/iar/: MIMXRT798Sxxxx_cm33_core0_flash.icf MIMXRT798Sxxxx_cm33_core0_ram.icf
  group source
    ../Core/source/: app.h display_support.c display_support.h FreeRTOSConfig_frag.h FreeRTOSConfig_Gen.h hardware_init.c lv_conf.h lvgl_demo_utils.c lvgl_demo_utils.h lvgl_freertos.c lvgl_freertos.h lvgl_guider.c lvgl_support.c lvgl_support.h mcux_config.h pin_mux.c pin_mux.h vglite_support.c vglite_support.h ZephyrMap_Gen.h
  group startup
    startup/: startup_MIMXRT798S_cm33_core0.c
  group touchpanel
    ../Core/touchpanel/: fsl_ft3267.c fsl_ft3267.h fsl_ft5406_rt.c fsl_ft5406_rt.h fsl_gt911.c fsl_gt911.h fsl_tma525b.c fsl_tma525b.h
  group utilities
    ../Core/utilities/: fsl_assert.c fsl_assert.h
  group utilities/debug_console_lite
    ../Core/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h
  group utilities/str
    ../Core/utilities/str/: fsl_str.c fsl_str.h
  group vglite
    ../Core/vglite/: LICENSE.txt RELEASE_NOTES.txt
  group vglite/inc
    ../Core/vglite/inc/: vg_lite.h
  group vglite/VGLite
    ../Core/vglite/VGLite/: vg_lite.c vg_lite_context.h vg_lite_image.c vg_lite_matrix.c vg_lite_options.h vg_lite_path.c vg_lite_stroke.c
  group vglite/VGLite/rtos
    ../Core/vglite/VGLite/rtos/: vg_lite_os.c
  group vglite/VGLite/Series/gc255/0x40A
    ../Core/vglite/VGLite/Series/gc255/0x40A/: vg_lite_options.h
  group vglite/VGLite/Series/gc355/0x0_1216
    ../Core/vglite/VGLite/Series/gc355/0x0_1216/: vg_lite_options.h
  group vglite/VGLite/Series/gc555/0x423_ECO
    ../Core/vglite/VGLite/Series/gc555/0x423_ECO/: vg_lite_options.h
  group vglite/VGLiteKernel
    ../Core/vglite/VGLiteKernel/: vg_lite_debug.h vg_lite_hal.h vg_lite_hw.h vg_lite_kernel.c vg_lite_kernel.h vg_lite_option.h vg_lite_type.h
  group vglite/VGLiteKernel/rtos
    ../Core/vglite/VGLiteKernel/rtos/: vg_lite_hal.c vg_lite_platform.h
  group video
    ../Core/video/: fsl_co5300.c fsl_co5300.h fsl_dbi.c fsl_dbi.h fsl_dbi_flexio_edma.c fsl_dbi_flexio_edma.h fsl_dbi_lcdif.c fsl_dbi_lcdif.h fsl_dc_fb.h fsl_dc_fb_dbi.c fsl_dc_fb_dbi.h fsl_dc_fb_dsi_cmd.c fsl_dc_fb_dsi_cmd.h fsl_dc_fb_lcdif.c fsl_dc_fb_lcdif.h fsl_display.h fsl_fbdev.c fsl_fbdev.h fsl_hx8394.c fsl_hx8394.h fsl_mipi_dsi_cmd.c fsl_mipi_dsi_cmd.h fsl_rm67162.c fsl_rm67162.h fsl_rm68191.c fsl_rm68191.h fsl_rm68200.c fsl_rm68200.h fsl_rpi.c fsl_rpi.h fsl_video_common.c fsl_video_common.h
